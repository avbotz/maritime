## tests/thruster/testcase.yaml
```yaml
tests:
  maritime.thruster:
    platform_allow:
      - native_sim/native/64
    integration_platforms:
      - native_sim/native/64
    tags: thruster
```
